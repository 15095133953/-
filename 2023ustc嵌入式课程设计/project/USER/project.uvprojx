# Keil uVision project project.uvprojx, settings and files
target Template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\STM32F10x_FWLib\inc;.\CORE;..\USER;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\LCD;.\HARDWARE\LED;.\HARDWARE\DHT11;.\HARDWARE\TOUCH;.\HARDWARE\usart2;.\HARDWARE\24CXX;.\HARDWARE\IIC;.\HARDWARE\TOUCH
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ./CORE/: startup_stm32f10x_hd.s core_cm3.c
  group FWLIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/LCD/: lcd.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/DHT11/: dht11.c
    ./HARDWARE/TOUCH/: touch.c ctiic.c ft5206.c gt9147.c ott2001a.c
    ./HARDWARE/usart2/: usart2.c
    ./HARDWARE/24CXX/: 24cxx.c
    ./HARDWARE/IIC/: myiic.c
